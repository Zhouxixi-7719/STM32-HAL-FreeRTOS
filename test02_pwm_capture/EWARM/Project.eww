<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\test02_pwm_capture.ewp</path>
  </project>
  <batchBuild />
</workspace>
